options:
  parameters:
    generate_options: qt_gui
    id: test
    output_language: python
    title: LoRaWAN Sniffer
  states: {}

blocks:
- name: bandwidth
  id: variable
  parameters:
    value: '125000'
  states: {state: disabled}
- name: channels
  id: variable
  parameters:
    value: '[frequency]'
  states: {}
- name: decode_downlink
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: frequency
  id: variable
  parameters:
    value: 867.6e6
  states: {state: disabled}
- name: low_pass_cutoff
  id: variable
  parameters:
    value: bandwidth*0.9
  states: {}
- name: low_pass_trans_width
  id: variable
  parameters:
    value: bandwidth*0.5
  states: {}
- name: rpp0_channelization_disable
  id: variable
  parameters:
    comment: |-
      True  - removes low pass filter for the receiver blocks to see the whole spectrum. 
      	   - Might degrade a signal quality, but enables multiple-channel decoding
    value: 'False'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {state: disabled}
- name: spreading_factor
  id: variable
  parameters:
    value: '7'
  states: {state: disabled}
- name: squelch_treshold
  id: variable
  parameters:
    value: '-60'
  states: {}
- name: analog_simple_squelch_cc_0_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: squelch_treshold
  states: {state: disabled}
- name: analog_simple_squelch_cc_0_0_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: squelch_treshold
  states: {state: disabled}
- name: analog_simple_squelch_cc_0_0_1
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: squelch_treshold
  states: {state: disabled}
- name: analog_simple_squelch_cc_0_0_2
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: squelch_treshold
  states: {state: disabled}
- name: analog_simple_squelch_cc_0_0_3
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: squelch_treshold
  states: {state: disabled}
- name: analog_simple_squelch_cc_0_0_4
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: squelch_treshold
  states: {state: disabled}
- name: analog_simple_squelch_cc_0_0_5
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: squelch_treshold
  states: {state: disabled}
- name: analog_simple_squelch_cc_0_0_6
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: squelch_treshold
  states: {state: disabled}
- name: analog_simple_squelch_cc_0_0_7
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: squelch_treshold
  states: {state: disabled}
- name: analog_simple_squelch_cc_0_0_8
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: squelch_treshold
  states: {state: disabled}
- name: analog_simple_squelch_cc_0_0_9
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: squelch_treshold
  states: {state: disabled}
- name: bandwidth
  id: parameter
  parameters:
    type: intx
    value: '125000'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '11'
    type: complex
  states: {state: disabled}
- name: blocks_freqshift_cc_0
  id: blocks_freqshift_cc
  parameters:
    comment: '867.1'
    freq: +900e3
    sample_rate: samp_rate
  states: {state: disabled}
- name: blocks_freqshift_cc_0_0
  id: blocks_freqshift_cc
  parameters:
    comment: '867.3'
    freq: +700e3
    sample_rate: samp_rate
  states: {}
- name: blocks_freqshift_cc_0_0_0
  id: blocks_freqshift_cc
  parameters:
    comment: '867.5'
    freq: +500e3
    sample_rate: samp_rate
  states: {}
- name: blocks_freqshift_cc_0_0_0_0
  id: blocks_freqshift_cc
  parameters:
    comment: '867.7'
    freq: +300e3
    sample_rate: samp_rate
  states: {}
- name: blocks_freqshift_cc_0_0_0_0_0
  id: blocks_freqshift_cc
  parameters:
    comment: '868.0'
    freq: '0'
    sample_rate: samp_rate
  states: {}
- name: blocks_freqshift_cc_0_0_0_0_1
  id: blocks_freqshift_cc
  parameters:
    comment: '867.9'
    freq: +100e3
    sample_rate: samp_rate
  states: {}
- name: blocks_freqshift_cc_0_0_0_0_1_0
  id: blocks_freqshift_cc
  parameters:
    comment: '868.1'
    freq: '-100e3'
    sample_rate: samp_rate
  states: {}
- name: blocks_freqshift_cc_0_0_0_0_2
  id: blocks_freqshift_cc
  parameters:
    comment: '868.3'
    freq: '-300e3'
    sample_rate: samp_rate
  states: {state: disabled}
- name: blocks_freqshift_cc_0_0_0_1
  id: blocks_freqshift_cc
  parameters:
    comment: '868.5'
    freq: '-500e3'
    sample_rate: samp_rate
  states: {state: disabled}
- name: blocks_freqshift_cc_0_0_1
  id: blocks_freqshift_cc
  parameters:
    comment: '868.7'
    freq: '-700e3'
    sample_rate: samp_rate
  states: {state: disabled}
- name: blocks_freqshift_cc_0_1
  id: blocks_freqshift_cc
  parameters:
    comment: '868.9'
    freq: '-900e3'
    sample_rate: samp_rate
  states: {state: disabled}
- name: frequency
  id: parameter
  parameters:
    type: eng_float
    value: 868e6
  states: {}
- name: gain_db
  id: parameter
  parameters:
    type: intx
    value: '10'
  states: {}
- name: lora_lora_receiver_0_0_0
  id: lora_lora_receiver
  parameters:
    bandwidth: bandwidth
    center_freq: frequency
    channel_list: channels
    conj: 'False'
    cr: '4'
    crc: 'True'
    decimation: '1'
    disable_channelization: rpp0_channelization_disable
    disable_drift_correction: 'False'
    implicit: 'False'
    reduced_rate: 'False'
    samp_rate: samp_rate
    sf: '8'
  states: {state: disabled}
- name: lora_lora_receiver_0_0_0_0
  id: lora_lora_receiver
  parameters:
    bandwidth: bandwidth
    center_freq: frequency
    channel_list: channels
    conj: 'False'
    cr: '4'
    crc: 'True'
    decimation: '1'
    disable_channelization: rpp0_channelization_disable
    disable_drift_correction: 'False'
    implicit: 'False'
    reduced_rate: 'False'
    samp_rate: samp_rate
    sf: '9'
  states: {state: disabled}
- name: lora_lora_receiver_0_0_0_0_0
  id: lora_lora_receiver
  parameters:
    bandwidth: bandwidth
    center_freq: frequency
    channel_list: channels
    conj: 'False'
    cr: '4'
    crc: 'True'
    decimation: '1'
    disable_channelization: rpp0_channelization_disable
    disable_drift_correction: 'False'
    implicit: 'False'
    reduced_rate: 'False'
    samp_rate: samp_rate
    sf: '10'
  states: {state: disabled}
- name: lora_lora_receiver_0_0_0_0_0_0
  id: lora_lora_receiver
  parameters:
    bandwidth: bandwidth
    center_freq: frequency
    channel_list: channels
    conj: 'False'
    cr: '4'
    crc: 'True'
    decimation: '1'
    disable_channelization: rpp0_channelization_disable
    disable_drift_correction: 'False'
    implicit: 'False'
    maxoutbuf: '13'
    minoutbuf: '13'
    reduced_rate: 'True'
    samp_rate: samp_rate
    sf: '11'
  states: {state: disabled}
- name: lora_lora_receiver_0_0_0_0_0_0_0
  id: lora_lora_receiver
  parameters:
    bandwidth: bandwidth
    center_freq: frequency
    channel_list: channels
    conj: 'False'
    cr: '4'
    crc: 'False'
    decimation: '1'
    disable_channelization: rpp0_channelization_disable
    disable_drift_correction: 'False'
    implicit: 'False'
    reduced_rate: 'True'
    samp_rate: samp_rate
    sf: '12'
  states: {state: disabled}
- name: lora_lora_receiver_0_0_4_1
  id: lora_lora_receiver
  parameters:
    bandwidth: bandwidth
    center_freq: frequency
    channel_list: channels
    conj: 'True'
    cr: '4'
    crc: 'True'
    decimation: '1'
    disable_channelization: rpp0_channelization_disable
    disable_drift_correction: 'False'
    implicit: 'False'
    reduced_rate: 'False'
    samp_rate: samp_rate
    sf: spreading_factor
  states: {state: disabled}
- name: lora_lora_receiver_0_0_4_1_0
  id: lora_lora_receiver
  parameters:
    bandwidth: bandwidth
    center_freq: frequency
    channel_list: channels
    conj: decode_downlink
    cr: '4'
    crc: 'True'
    decimation: '1'
    disable_channelization: rpp0_channelization_disable
    disable_drift_correction: 'False'
    implicit: 'False'
    reduced_rate: 'False'
    samp_rate: samp_rate
    sf: spreading_factor
  states: {state: disabled}
- name: lora_lora_receiver_0_0_4_1_1
  id: lora_lora_receiver
  parameters:
    bandwidth: bandwidth
    center_freq: frequency
    channel_list: channels
    conj: 'False'
    cr: '4'
    crc: 'True'
    decimation: '1'
    disable_channelization: rpp0_channelization_disable
    disable_drift_correction: 'False'
    implicit: 'False'
    reduced_rate: 'False'
    samp_rate: samp_rate
    sf: spreading_factor
  states: {state: disabled}
- name: lora_lora_receiver_0_0_4_1_10
  id: lora_lora_receiver
  parameters:
    bandwidth: bandwidth
    center_freq: frequency
    channel_list: channels
    conj: 'True'
    cr: '4'
    crc: 'True'
    decimation: '1'
    disable_channelization: rpp0_channelization_disable
    disable_drift_correction: 'False'
    implicit: 'False'
    reduced_rate: 'False'
    samp_rate: samp_rate
    sf: spreading_factor
  states: {state: disabled}
- name: lora_lora_receiver_0_0_4_1_11
  id: lora_lora_receiver
  parameters:
    bandwidth: bandwidth
    center_freq: frequency
    channel_list: channels
    conj: 'True'
    cr: '4'
    crc: 'True'
    decimation: '1'
    disable_channelization: rpp0_channelization_disable
    disable_drift_correction: 'False'
    implicit: 'False'
    reduced_rate: 'False'
    samp_rate: samp_rate
    sf: spreading_factor
  states: {state: disabled}
- name: lora_lora_receiver_0_0_4_1_1_0
  id: lora_lora_receiver
  parameters:
    bandwidth: bandwidth
    center_freq: frequency
    channel_list: channels
    conj: 'False'
    cr: '4'
    crc: 'True'
    decimation: '1'
    disable_channelization: rpp0_channelization_disable
    disable_drift_correction: 'False'
    implicit: 'False'
    reduced_rate: 'False'
    samp_rate: samp_rate
    sf: spreading_factor
  states: {state: disabled}
- name: lora_lora_receiver_0_0_4_1_1_1
  id: lora_lora_receiver
  parameters:
    bandwidth: bandwidth
    center_freq: frequency
    channel_list: channels
    conj: 'False'
    cr: '4'
    crc: 'True'
    decimation: '1'
    disable_channelization: rpp0_channelization_disable
    disable_drift_correction: 'False'
    implicit: 'False'
    reduced_rate: 'False'
    samp_rate: samp_rate
    sf: spreading_factor
  states: {state: disabled}
- name: lora_lora_receiver_0_0_4_1_1_2
  id: lora_lora_receiver
  parameters:
    bandwidth: bandwidth
    center_freq: frequency
    channel_list: channels
    conj: 'False'
    cr: '4'
    crc: 'True'
    decimation: '1'
    disable_channelization: rpp0_channelization_disable
    disable_drift_correction: 'False'
    implicit: 'False'
    reduced_rate: 'False'
    samp_rate: samp_rate
    sf: spreading_factor
  states: {state: disabled}
- name: lora_lora_receiver_0_0_4_1_1_3
  id: lora_lora_receiver
  parameters:
    bandwidth: bandwidth
    center_freq: frequency
    channel_list: channels
    conj: 'False'
    cr: '4'
    crc: 'True'
    decimation: '1'
    disable_channelization: rpp0_channelization_disable
    disable_drift_correction: 'False'
    implicit: 'False'
    reduced_rate: 'False'
    samp_rate: samp_rate
    sf: spreading_factor
  states: {state: disabled}
- name: lora_lora_receiver_0_0_4_1_1_4
  id: lora_lora_receiver
  parameters:
    bandwidth: bandwidth
    center_freq: frequency
    channel_list: channels
    conj: 'False'
    cr: '4'
    crc: 'True'
    decimation: '1'
    disable_channelization: rpp0_channelization_disable
    disable_drift_correction: 'False'
    implicit: 'False'
    reduced_rate: 'False'
    samp_rate: samp_rate
    sf: spreading_factor
  states: {state: disabled}
- name: lora_lora_receiver_0_0_4_1_1_5
  id: lora_lora_receiver
  parameters:
    bandwidth: bandwidth
    center_freq: frequency
    channel_list: channels
    conj: 'False'
    cr: '4'
    crc: 'True'
    decimation: '1'
    disable_channelization: rpp0_channelization_disable
    disable_drift_correction: 'False'
    implicit: 'False'
    reduced_rate: 'False'
    samp_rate: samp_rate
    sf: spreading_factor
  states: {state: disabled}
- name: lora_lora_receiver_0_0_4_1_1_6
  id: lora_lora_receiver
  parameters:
    bandwidth: bandwidth
    center_freq: frequency
    channel_list: channels
    conj: 'False'
    cr: '4'
    crc: 'True'
    decimation: '1'
    disable_channelization: rpp0_channelization_disable
    disable_drift_correction: 'False'
    implicit: 'False'
    reduced_rate: 'False'
    samp_rate: samp_rate
    sf: spreading_factor
  states: {state: disabled}
- name: lora_lora_receiver_0_0_4_1_1_7
  id: lora_lora_receiver
  parameters:
    bandwidth: bandwidth
    center_freq: frequency
    channel_list: channels
    conj: 'False'
    cr: '4'
    crc: 'True'
    decimation: '1'
    disable_channelization: rpp0_channelization_disable
    disable_drift_correction: 'False'
    implicit: 'False'
    reduced_rate: 'False'
    samp_rate: samp_rate
    sf: spreading_factor
  states: {state: disabled}
- name: lora_lora_receiver_0_0_4_1_1_8
  id: lora_lora_receiver
  parameters:
    bandwidth: bandwidth
    center_freq: frequency
    channel_list: channels
    conj: 'False'
    cr: '4'
    crc: 'True'
    decimation: '1'
    disable_channelization: rpp0_channelization_disable
    disable_drift_correction: 'False'
    implicit: 'False'
    reduced_rate: 'False'
    samp_rate: samp_rate
    sf: spreading_factor
  states: {state: disabled}
- name: lora_lora_receiver_0_0_4_1_1_9
  id: lora_lora_receiver
  parameters:
    bandwidth: bandwidth
    center_freq: frequency
    channel_list: channels
    conj: 'False'
    cr: '4'
    crc: 'True'
    decimation: '1'
    disable_channelization: rpp0_channelization_disable
    disable_drift_correction: 'False'
    implicit: 'False'
    reduced_rate: 'False'
    samp_rate: samp_rate
    sf: spreading_factor
  states: {state: disabled}
- name: lora_lora_receiver_0_0_4_1_2
  id: lora_lora_receiver
  parameters:
    bandwidth: bandwidth
    center_freq: frequency
    channel_list: channels
    conj: 'True'
    cr: '4'
    crc: 'True'
    decimation: '1'
    disable_channelization: rpp0_channelization_disable
    disable_drift_correction: 'False'
    implicit: 'False'
    reduced_rate: 'False'
    samp_rate: samp_rate
    sf: spreading_factor
  states: {}
- name: lora_lora_receiver_0_0_4_1_3
  id: lora_lora_receiver
  parameters:
    bandwidth: bandwidth
    center_freq: frequency
    channel_list: channels
    conj: 'True'
    cr: '4'
    crc: 'True'
    decimation: '1'
    disable_channelization: rpp0_channelization_disable
    disable_drift_correction: 'False'
    implicit: 'False'
    reduced_rate: 'False'
    samp_rate: samp_rate
    sf: spreading_factor
  states: {}
- name: lora_lora_receiver_0_0_4_1_4
  id: lora_lora_receiver
  parameters:
    bandwidth: bandwidth
    center_freq: frequency
    channel_list: channels
    conj: 'True'
    cr: '4'
    crc: 'True'
    decimation: '1'
    disable_channelization: rpp0_channelization_disable
    disable_drift_correction: 'False'
    implicit: 'False'
    reduced_rate: 'False'
    samp_rate: samp_rate
    sf: spreading_factor
  states: {}
- name: lora_lora_receiver_0_0_4_1_5
  id: lora_lora_receiver
  parameters:
    bandwidth: bandwidth
    center_freq: frequency
    channel_list: channels
    conj: 'True'
    cr: '4'
    crc: 'True'
    decimation: '1'
    disable_channelization: rpp0_channelization_disable
    disable_drift_correction: 'False'
    implicit: 'False'
    reduced_rate: 'False'
    samp_rate: samp_rate
    sf: spreading_factor
  states: {}
- name: lora_lora_receiver_0_0_4_1_6
  id: lora_lora_receiver
  parameters:
    bandwidth: bandwidth
    center_freq: frequency
    channel_list: channels
    conj: 'True'
    cr: '4'
    crc: 'True'
    decimation: '1'
    disable_channelization: rpp0_channelization_disable
    disable_drift_correction: 'False'
    implicit: 'False'
    reduced_rate: 'False'
    samp_rate: samp_rate
    sf: spreading_factor
  states: {}
- name: lora_lora_receiver_0_0_4_1_7
  id: lora_lora_receiver
  parameters:
    bandwidth: bandwidth
    center_freq: frequency
    channel_list: channels
    conj: 'True'
    cr: '4'
    crc: 'True'
    decimation: '1'
    disable_channelization: rpp0_channelization_disable
    disable_drift_correction: 'False'
    implicit: 'False'
    reduced_rate: 'False'
    samp_rate: samp_rate
    sf: spreading_factor
  states: {}
- name: lora_lora_receiver_0_0_4_1_8
  id: lora_lora_receiver
  parameters:
    bandwidth: bandwidth
    center_freq: frequency
    channel_list: channels
    conj: 'True'
    cr: '4'
    crc: 'True'
    decimation: '1'
    disable_channelization: rpp0_channelization_disable
    disable_drift_correction: 'False'
    implicit: 'False'
    reduced_rate: 'False'
    samp_rate: samp_rate
    sf: spreading_factor
  states: {state: disabled}
- name: lora_lora_receiver_0_0_4_1_9
  id: lora_lora_receiver
  parameters:
    bandwidth: bandwidth
    center_freq: frequency
    channel_list: channels
    conj: 'True'
    cr: '4'
    crc: 'True'
    decimation: '1'
    disable_channelization: rpp0_channelization_disable
    disable_drift_correction: 'False'
    implicit: 'False'
    reduced_rate: 'False'
    samp_rate: samp_rate
    sf: spreading_factor
  states: {state: disabled}
- name: lora_message_socket_sink_0
  id: lora_message_socket_sink
  parameters:
    ip: 127.0.0.1
    layer: '1'
    port: '7890'
  states: {state: disabled}
- name: lora_message_socket_sink_1
  id: lora_message_socket_sink
  parameters:
    ip: 127.0.0.1
    layer: '1'
    port: '40868'
  states: {}
- name: lora_rx_1
  id: lora_rx
  parameters:
    bw: bandwidth
    cr: '1'
    has_crc: 'True'
    impl_head: 'False'
    ldro: '0'
    pay_len: '255'
    print_rx: '[True,True]'
    samp_rate: samp_rate
    sf: '11'
    soft_decoding: 'False'
    sync_word: '[0x12]'
  states: {state: disabled}
- name: lora_rx_1_0
  id: lora_rx
  parameters:
    bw: bandwidth
    cr: '1'
    has_crc: 'True'
    impl_head: 'False'
    ldro: '2'
    pay_len: '255'
    print_rx: '[True,True]'
    samp_rate: samp_rate
    sf: '12'
    soft_decoding: 'True'
    sync_word: '[0x12]'
  states: {state: disabled}
- name: lora_rx_1_1
  id: lora_rx
  parameters:
    bw: bandwidth
    cr: '1'
    has_crc: 'True'
    impl_head: 'False'
    ldro: '2'
    pay_len: '255'
    print_rx: '[True,True]'
    samp_rate: samp_rate
    sf: '7'
    soft_decoding: 'False'
    sync_word: '[0x12]'
  states: {state: disabled}
- name: lora_rx_1_1_0
  id: lora_rx
  parameters:
    bw: bandwidth
    cr: '1'
    has_crc: 'True'
    impl_head: 'False'
    ldro: '2'
    pay_len: '255'
    print_rx: '[True,True]'
    samp_rate: samp_rate
    sf: '8'
    soft_decoding: 'False'
    sync_word: '[0x12]'
  states: {state: disabled}
- name: lora_rx_1_1_1
  id: lora_rx
  parameters:
    bw: bandwidth
    cr: '1'
    has_crc: 'True'
    impl_head: 'False'
    ldro: '2'
    pay_len: '255'
    print_rx: '[True,True]'
    samp_rate: samp_rate
    sf: '9'
    soft_decoding: 'False'
    sync_word: '[0x12]'
  states: {state: disabled}
- name: lora_rx_1_1_1_0
  id: lora_rx
  parameters:
    bw: bandwidth
    cr: '1'
    has_crc: 'True'
    impl_head: 'False'
    ldro: '2'
    pay_len: '255'
    print_rx: '[True,True]'
    samp_rate: samp_rate
    sf: '10'
    soft_decoding: 'False'
    sync_word: '[0x12]'
  states: {state: disabled}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: low_pass_cutoff
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: low_pass_trans_width
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: low_pass_cutoff
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: low_pass_trans_width
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: low_pass_filter_0_1
  id: low_pass_filter
  parameters:
    cutoff_freq: low_pass_cutoff
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: low_pass_trans_width
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: low_pass_filter_0_2
  id: low_pass_filter
  parameters:
    cutoff_freq: low_pass_cutoff
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: low_pass_trans_width
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: low_pass_filter_0_3
  id: low_pass_filter
  parameters:
    cutoff_freq: low_pass_cutoff
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: low_pass_trans_width
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: low_pass_filter_0_4
  id: low_pass_filter
  parameters:
    cutoff_freq: low_pass_cutoff
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: low_pass_trans_width
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: low_pass_filter_0_4_0
  id: low_pass_filter
  parameters:
    cutoff_freq: low_pass_cutoff
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: low_pass_trans_width
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: low_pass_filter_0_4_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: low_pass_cutoff
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: low_pass_trans_width
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: low_pass_filter_0_4_0_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: low_pass_cutoff
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: low_pass_trans_width
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: low_pass_filter_0_4_1
  id: low_pass_filter
  parameters:
    cutoff_freq: low_pass_cutoff
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: low_pass_trans_width
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: low_pass_filter_0_4_2
  id: low_pass_filter
  parameters:
    cutoff_freq: low_pass_cutoff
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: low_pass_trans_width
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: note_0
  id: note
  parameters:
    note: export PYTHONPATH=/usr/local/lib/3.10/dist-packages:/usr/lib/3.10/site-packages:$PYTHONPATH
  states: {}
- name: note_1
  id: note
  parameters:
    note: export LD_LIBRARY_PATH=/usr/local/lib:$LD_LIBRARY_PATH
  states: {}
- name: qtgui_sink_x_0_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: frequency
    fftsize: '1024'
    type: complex
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    type: intx
    value: '1000000'
  states: {}
- name: soapy_hackrf_source_0
  id: soapy_hackrf_source
  parameters:
    center_freq: frequency
    gain: '12'
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: spreading_factor
  id: parameter
  parameters:
    type: intx
    value: '7'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: frequency
    gain0: gain_db
    minoutbuf: '100000'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}

connections:
- [analog_simple_squelch_cc_0_0, '0', blocks_add_xx_0, '0']
- [analog_simple_squelch_cc_0_0_0, '0', blocks_add_xx_0, '1']
- [analog_simple_squelch_cc_0_0_1, '0', blocks_add_xx_0, '4']
- [analog_simple_squelch_cc_0_0_2, '0', blocks_add_xx_0, '2']
- [analog_simple_squelch_cc_0_0_3, '0', blocks_add_xx_0, '3']
- [analog_simple_squelch_cc_0_0_4, '0', blocks_add_xx_0, '5']
- [analog_simple_squelch_cc_0_0_5, '0', blocks_add_xx_0, '8']
- [analog_simple_squelch_cc_0_0_6, '0', blocks_add_xx_0, '6']
- [analog_simple_squelch_cc_0_0_7, '0', blocks_add_xx_0, '7']
- [analog_simple_squelch_cc_0_0_8, '0', blocks_add_xx_0, '9']
- [analog_simple_squelch_cc_0_0_9, '0', blocks_add_xx_0, '10']
- [blocks_add_xx_0, '0', lora_lora_receiver_0_0_4_1_0, '0']
- [blocks_freqshift_cc_0, '0', lora_lora_receiver_0_0_4_1, '0']
- [blocks_freqshift_cc_0, '0', lora_lora_receiver_0_0_4_1_1, '0']
- [blocks_freqshift_cc_0, '0', low_pass_filter_0_4_0_0_0, '0']
- [blocks_freqshift_cc_0_0, '0', lora_lora_receiver_0_0_4_1_1_0, '0']
- [blocks_freqshift_cc_0_0, '0', lora_lora_receiver_0_0_4_1_2, '0']
- [blocks_freqshift_cc_0_0, '0', low_pass_filter_0_4_0_0, '0']
- [blocks_freqshift_cc_0_0_0, '0', lora_lora_receiver_0_0_4_1_1_1, '0']
- [blocks_freqshift_cc_0_0_0, '0', lora_lora_receiver_0_0_4_1_3, '0']
- [blocks_freqshift_cc_0_0_0, '0', low_pass_filter_0_4_0, '0']
- [blocks_freqshift_cc_0_0_0_0, '0', lora_lora_receiver_0_0_4_1_1_2, '0']
- [blocks_freqshift_cc_0_0_0_0, '0', lora_lora_receiver_0_0_4_1_4, '0']
- [blocks_freqshift_cc_0_0_0_0, '0', low_pass_filter_0_4_2, '0']
- [blocks_freqshift_cc_0_0_0_0_0, '0', lora_lora_receiver_0_0_4_1_1_4, '0']
- [blocks_freqshift_cc_0_0_0_0_0, '0', lora_lora_receiver_0_0_4_1_6, '0']
- [blocks_freqshift_cc_0_0_0_0_0, '0', low_pass_filter_0_4, '0']
- [blocks_freqshift_cc_0_0_0_0_1, '0', lora_lora_receiver_0_0_4_1_1_3, '0']
- [blocks_freqshift_cc_0_0_0_0_1, '0', lora_lora_receiver_0_0_4_1_5, '0']
- [blocks_freqshift_cc_0_0_0_0_1, '0', low_pass_filter_0_4_1, '0']
- [blocks_freqshift_cc_0_0_0_0_1_0, '0', lora_lora_receiver_0_0_4_1_1_5, '0']
- [blocks_freqshift_cc_0_0_0_0_1_0, '0', lora_lora_receiver_0_0_4_1_7, '0']
- [blocks_freqshift_cc_0_0_0_0_1_0, '0', low_pass_filter_0, '0']
- [blocks_freqshift_cc_0_0_0_0_2, '0', lora_lora_receiver_0_0_4_1_1_6, '0']
- [blocks_freqshift_cc_0_0_0_0_2, '0', lora_lora_receiver_0_0_4_1_8, '0']
- [blocks_freqshift_cc_0_0_0_0_2, '0', low_pass_filter_0_3, '0']
- [blocks_freqshift_cc_0_0_0_1, '0', lora_lora_receiver_0_0_4_1_1_7, '0']
- [blocks_freqshift_cc_0_0_0_1, '0', lora_lora_receiver_0_0_4_1_9, '0']
- [blocks_freqshift_cc_0_0_0_1, '0', low_pass_filter_0_2, '0']
- [blocks_freqshift_cc_0_0_1, '0', lora_lora_receiver_0_0_4_1_10, '0']
- [blocks_freqshift_cc_0_0_1, '0', lora_lora_receiver_0_0_4_1_1_8, '0']
- [blocks_freqshift_cc_0_0_1, '0', low_pass_filter_0_1, '0']
- [blocks_freqshift_cc_0_1, '0', lora_lora_receiver_0_0_4_1_11, '0']
- [blocks_freqshift_cc_0_1, '0', lora_lora_receiver_0_0_4_1_1_9, '0']
- [blocks_freqshift_cc_0_1, '0', low_pass_filter_0_0, '0']
- [lora_lora_receiver_0_0_0, frames, lora_message_socket_sink_0, in]
- [lora_lora_receiver_0_0_0_0, frames, lora_message_socket_sink_0, in]
- [lora_lora_receiver_0_0_0_0_0, frames, lora_message_socket_sink_0, in]
- [lora_lora_receiver_0_0_0_0_0_0, frames, lora_message_socket_sink_0, in]
- [lora_lora_receiver_0_0_0_0_0_0_0, frames, lora_message_socket_sink_0, in]
- [lora_lora_receiver_0_0_4_1, frames, lora_message_socket_sink_1, in]
- [lora_lora_receiver_0_0_4_1_0, frames, lora_message_socket_sink_1, in]
- [lora_lora_receiver_0_0_4_1_1, frames, lora_message_socket_sink_1, in]
- [lora_lora_receiver_0_0_4_1_10, frames, lora_message_socket_sink_1, in]
- [lora_lora_receiver_0_0_4_1_11, frames, lora_message_socket_sink_1, in]
- [lora_lora_receiver_0_0_4_1_1_0, frames, lora_message_socket_sink_1, in]
- [lora_lora_receiver_0_0_4_1_1_1, frames, lora_message_socket_sink_1, in]
- [lora_lora_receiver_0_0_4_1_1_2, frames, lora_message_socket_sink_1, in]
- [lora_lora_receiver_0_0_4_1_1_3, frames, lora_message_socket_sink_1, in]
- [lora_lora_receiver_0_0_4_1_1_4, frames, lora_message_socket_sink_1, in]
- [lora_lora_receiver_0_0_4_1_1_5, frames, lora_message_socket_sink_1, in]
- [lora_lora_receiver_0_0_4_1_1_6, frames, lora_message_socket_sink_1, in]
- [lora_lora_receiver_0_0_4_1_1_7, frames, lora_message_socket_sink_1, in]
- [lora_lora_receiver_0_0_4_1_1_8, frames, lora_message_socket_sink_1, in]
- [lora_lora_receiver_0_0_4_1_1_9, frames, lora_message_socket_sink_1, in]
- [lora_lora_receiver_0_0_4_1_2, frames, lora_message_socket_sink_1, in]
- [lora_lora_receiver_0_0_4_1_3, frames, lora_message_socket_sink_1, in]
- [lora_lora_receiver_0_0_4_1_4, frames, lora_message_socket_sink_1, in]
- [lora_lora_receiver_0_0_4_1_5, frames, lora_message_socket_sink_1, in]
- [lora_lora_receiver_0_0_4_1_6, frames, lora_message_socket_sink_1, in]
- [lora_lora_receiver_0_0_4_1_7, frames, lora_message_socket_sink_1, in]
- [lora_lora_receiver_0_0_4_1_8, frames, lora_message_socket_sink_1, in]
- [lora_lora_receiver_0_0_4_1_9, frames, lora_message_socket_sink_1, in]
- [low_pass_filter_0, '0', analog_simple_squelch_cc_0_0_6, '0']
- [low_pass_filter_0_0, '0', analog_simple_squelch_cc_0_0_9, '0']
- [low_pass_filter_0_1, '0', analog_simple_squelch_cc_0_0_8, '0']
- [low_pass_filter_0_2, '0', analog_simple_squelch_cc_0_0_5, '0']
- [low_pass_filter_0_3, '0', analog_simple_squelch_cc_0_0_7, '0']
- [low_pass_filter_0_4, '0', analog_simple_squelch_cc_0_0_4, '0']
- [low_pass_filter_0_4_0, '0', analog_simple_squelch_cc_0_0_2, '0']
- [low_pass_filter_0_4_0_0, '0', analog_simple_squelch_cc_0_0_0, '0']
- [low_pass_filter_0_4_0_0_0, '0', analog_simple_squelch_cc_0_0, '0']
- [low_pass_filter_0_4_1, '0', analog_simple_squelch_cc_0_0_1, '0']
- [low_pass_filter_0_4_2, '0', analog_simple_squelch_cc_0_0_3, '0']
- [soapy_hackrf_source_0, '0', blocks_freqshift_cc_0, '0']
- [soapy_hackrf_source_0, '0', blocks_freqshift_cc_0_0, '0']
- [soapy_hackrf_source_0, '0', blocks_freqshift_cc_0_0_0, '0']
- [soapy_hackrf_source_0, '0', blocks_freqshift_cc_0_0_0_0, '0']
- [soapy_hackrf_source_0, '0', blocks_freqshift_cc_0_0_0_0_0, '0']
- [soapy_hackrf_source_0, '0', blocks_freqshift_cc_0_0_0_0_1, '0']
- [soapy_hackrf_source_0, '0', blocks_freqshift_cc_0_0_0_0_1_0, '0']
- [soapy_hackrf_source_0, '0', blocks_freqshift_cc_0_0_0_0_2, '0']
- [soapy_hackrf_source_0, '0', blocks_freqshift_cc_0_0_0_1, '0']
- [soapy_hackrf_source_0, '0', blocks_freqshift_cc_0_0_1, '0']
- [soapy_hackrf_source_0, '0', blocks_freqshift_cc_0_1, '0']
- [soapy_hackrf_source_0, '0', qtgui_sink_x_0_0_0, '0']
- [uhd_usrp_source_0, '0', blocks_freqshift_cc_0, '0']
- [uhd_usrp_source_0, '0', blocks_freqshift_cc_0_0, '0']
- [uhd_usrp_source_0, '0', blocks_freqshift_cc_0_0_0, '0']
- [uhd_usrp_source_0, '0', blocks_freqshift_cc_0_0_0_0, '0']
- [uhd_usrp_source_0, '0', blocks_freqshift_cc_0_0_0_0_0, '0']
- [uhd_usrp_source_0, '0', blocks_freqshift_cc_0_0_0_0_1, '0']
- [uhd_usrp_source_0, '0', blocks_freqshift_cc_0_0_0_0_1_0, '0']
- [uhd_usrp_source_0, '0', blocks_freqshift_cc_0_0_0_0_2, '0']
- [uhd_usrp_source_0, '0', blocks_freqshift_cc_0_0_0_1, '0']
- [uhd_usrp_source_0, '0', blocks_freqshift_cc_0_0_1, '0']
- [uhd_usrp_source_0, '0', blocks_freqshift_cc_0_1, '0']
- [uhd_usrp_source_0, '0', qtgui_sink_x_0_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
